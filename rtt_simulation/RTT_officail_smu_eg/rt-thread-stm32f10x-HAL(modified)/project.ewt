<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applications</name>
    <file>
      <name>$PROJ_DIR$\applications\main.c</name>
    </file>
  </group>
  <group>
    <name>CORTEX-M3</name>
    <file>
      <name>$PROJ_DIR$\rt-thread\libcpu\arm\common\backtrace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\libcpu\arm\cortex-m3\cpuport.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\libcpu\arm\common\div0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\libcpu\arm\common\showmem.c</name>
    </file>
  </group>
  <group>
    <name>DeviceDrivers</name>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\src\completion.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\src\dataqueue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\misc\pin.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\src\pipe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\src\ringbuffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\serial\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\src\waitqueue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\drivers\src\workqueue.c</name>
    </file>
  </group>
  <group>
    <name>dlib</name>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\environ.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\libc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\rmtx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\stdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_close.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_lseek.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_open.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_read.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_remove.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\syscall_write.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\libc\compilers\dlib\time.c</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <file>
      <name>$PROJ_DIR$\drivers\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\drv_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\drv_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\stm32f1xx_it.c</name>
    </file>
  </group>
  <group>
    <name>finsh</name>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\finsh\cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\finsh\msh.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\finsh\msh_cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\finsh\msh_file.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\finsh\shell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\components\finsh\symbol.c</name>
    </file>
  </group>
  <group>
    <name>Kernel</name>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\components.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\idle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\ipc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\irq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\kservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\memheap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\mempool.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\object.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\scheduler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\signal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\thread.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rt-thread\src\timer.c</name>
    </file>
  </group>
  <group>
    <name>STM32_HAL</name>
    <file>
      <name>$PROJ_DIR$\Libraries\CMSIS\Device\ST\STM32F1xx\Source\Templates\iar\startup_stm32f103xe.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cortex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dac_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_irda.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_mmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_nand.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_nor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pccard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pcd_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_smartcard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_spi_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_sram.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_wwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_sdmmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_usb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F1xx_HAL_Driver\Src\stm32f1xx_ll_utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\CMSIS\Device\ST\STM32F1xx\Source\Templates\system_stm32f1xx.c</name>
    </file>
  </group>
</project>


