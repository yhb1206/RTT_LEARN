# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32l4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475ZETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32l4xx
  AfterMake: fromelf --bin !L --output rt-thread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32L475xx
  c include: applications;.;drivers;Libraries\STM32L4xx_HAL_Driver\Inc;Libraries\CMSIS\Device\ST\STM32L4xx\Include;Libraries\CMSIS\Include;test;.;rt-thread\include;rt-thread\libcpu\arm\cortex-m4;rt-thread\libcpu\arm\common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --keep *.o(.rti_fn.*)
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_clock.c
  group STM32L4xx_HAL_Driver
    Libraries/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_ll_gpio.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
    Libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    Libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
    ./Libraries/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_uart_ex.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c object.c scheduler.c signal.c thread.c timer.c
    ./rt-thread/src/: mem.c
  group CORTEX-M4
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
software components: CMSIS:CORE 5.0.1
