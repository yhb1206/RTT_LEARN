# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Fire_RT-Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_RT-Thread +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\bsp\usart;..\..\User\bsp\led;..\..\User\bsp\usart;..\..\User\bsp\Key;..\..\rtthread\bsp;..\..\rtthread\components\drivers;..\..\rtthread\components\drivers\include;..\..\rtthread\components\drivers\include\drivers;..\..\rtthread\components\drivers\include\ipc;..\..\rtthread\components\finsh;..\..\rtthread\bsp;..\..\rtthread\include;..\..\rtthread\include\libc;..\..\rtthread\bsp\STM32f103
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/bsp/Key/: bsp_key.c
    ../../User/bsp/usart/: bsp_usart.h bsp_usart.c
    ../../User/bsp/led/: bsp_led.h bsp_led.c
  group rtt_kernal
    ../../rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtt_cpulib
    ../../rtthread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group rtt_device_driver
    ../../rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rtthread/components/drivers/serial/: serial.c
  group rtt_finsh
    ../../rtthread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group rtt_bsp
    ../../rtthread/bsp/: rtconfig.h
    ../../rtthread/bsp/STM32f103/: board.c usart.c
